* SPICE3 file created from dlatch.ext - technology: scmos
.option scale=1u
M1000 Q A vdd Vdd pfet w=6 l=2
+ ad=52 pd=44 as=130 ps=110
M1001 Q Qn vdd Vdd pfet w=6 l=2
+ ad=0 pd=0 as=0 ps=0
M1002 An A vdd Vdd pfet w=6 l=2
+ ad=26 pd=22 as=0 ps=0
M1003 Qn An vdd Vdd pfet w=6 l=2
+ ad=52 pd=44 as=0 ps=0
M1004 Qn Q vdd Vdd pfet w=6 l=2
+ ad=0 pd=0 as=0 ps=0
M1005 x A 0 Gnd nfet w=6 l=2
+ ad=52 pd=44 as=78 ps=66
M1006 Q Qn x Gnd nfet w=6 l=2
+ ad=26 pd=22 as=0 ps=0
M1007 An A 0 Gnd nfet w=6 l=2
+ ad=26 pd=22 as=0 ps=0
M1008 y An 0 Gnd nfet w=6 l=2
+ ad=52 pd=44 as=0 ps=0
M1009 Qn Q y Gnd nfet w=6 l=2
+ ad=26 pd=22 as=0 ps=0
C0 vdd gnd! 17.3fF
C1 Q gnd! 21.2fF
C2 Qn gnd! 23.8fF
