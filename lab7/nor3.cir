* SPICE3 file created from nor3.ext - technology: scmos
.option scale=1u
M1000 out A 0 Gnd nfet w=3 l=2
+ ad=57 pd=54 as=57 ps=54
M1001 out A Y Vdd pfet w=6 l=2
+ ad=26 pd=22 as=52 ps=44
M1002 out B 0 Gnd nfet w=3 l=2
+ ad=0 pd=0 as=0 ps=0
M1003 Y B X Vdd pfet w=6 l=2
+ ad=0 pd=0 as=52 ps=44
M1004 out C 0 Gnd nfet w=3 l=2
+ ad=0 pd=0 as=0 ps=0
M1005 X C vdd Vdd pfet w=6 l=2
+ ad=0 pd=0 as=26 ps=22
C0 X gnd! 2.9fF
C1 Y gnd! 2.9fF
C2 out gnd! 7.6fF
